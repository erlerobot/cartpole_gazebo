Commit message: Fixing URDF

File: urdf/carpole_gazebo_urdf.xacro.urdf (robot description, URDF)
Before this commit: robot cartopole, 4 links, 3 joints
Joints:
- joint slider_to_cart: limit lower=-15 upper=15 effort=1000.0 velocity=3 -> lower=-15 upper=15 effort=1000.0 velocity=30
